# Keil uVision project Project_Template.uvproj, settings and files
target Project (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFBFF) CLOCK(33177600)
  output: Project_Template +hex
  link misc: CLASSES(CODE(0xFF0000-0xFFFBFF),HCONST(0xFF0000-0xFFFBFF),CONST(0xFF0000-0xFFFBFF))
  group startup
    ../../../Libraries/startup/src/: common.c
    ../../../Libraries/startup/inc/: STC32Gxx.h common.h STC32_MDU32_LARGE_V1.1.LIB
  group user
    ../USER/src/: isr.c main.c
    ../USER/inc/: main.h isr.h
  group boards
    ../../../Libraries/boards/src/: BMI088driver.c BMI088Middleware.c Encoder.c OLED.c LCD.c Font.c remote_control.c nrf24l01.c Ci24R1.c
    ../../../Libraries/boards/inc/: BMI088driver.h BMI088Middleware.h BMI088reg.h Ci24R1.h Encoder.h Font.h LCD.h nrf24l01.h OLED.h remote_control.h
  group drivers
    ../../../Libraries/deivers/src/: CNU_PIE_GPIO.c CNU_PIE_TIMER.c CNU_PIE_EXTI.c CNU_PIE_ADC.c CNU_PIE_I2C.c CNU_PIE_SPI.c CNU_PIE_PWM.c CNU_PIE_WDog.c CNU_PIE_UART.c CNU_PIE_FIFO.c
    ../../../Libraries/deivers/inc/: CNU_PIE_GPIO.h CNU_PIE_TIMER.h CNU_PIE_EXTI.h CNU_PIE_ADC.h CNU_PIE_I2C.h CNU_PIE_SPI.h CNU_PIE_PWM.h CNU_PIE_WDog.h CNU_PIE_UART.h CNU_PIE_FIFO.h
  group application
    ../USER/inc/: track_app.h track_config.h track_core.h track_font.h track_hw.h track_pid.h track_speed.h
    ../USER/src/: track_app.c track_core.c track_hw.c track_pid.c track_speed.c track_store.c
